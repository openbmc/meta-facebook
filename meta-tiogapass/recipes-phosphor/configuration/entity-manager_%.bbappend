FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Add-16-bit-addressing-EEPROM-handling.patch"
