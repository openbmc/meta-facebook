FILESEXTRAPATHS_prepend_yosemitev2 := "${THISDIR}/${PN}:"
