FILESEXTRAPATHS_prepend_tiogapass := "${THISDIR}/${PN}:"
FILESEXTRAPATHS_prepend_yosemitev2 := "${THISDIR}/${PN}:"
